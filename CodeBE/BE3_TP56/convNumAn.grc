<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resamp</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scale</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>scale</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>scale</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/tarnagda/Documents/Transmission2/WAVs/peas.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>vocoder_cvsd_decode_bf</key>
<param><key>id</key><value>vocoder_cvsd_decode_bf_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>resample</key><value>resamp</value></param>
</block>
<block>
<key>vocoder_cvsd_encode_fb</key>
<param><key>id</key><value>vocoder_cvsd_encode_fb_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>resample</key><value>resamp</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>vocoder_cvsd_encode_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_cvsd_decode_bf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_cvsd_encode_fb_0</source_block_id><sink_block_id>vocoder_cvsd_decode_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
